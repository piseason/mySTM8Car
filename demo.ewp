# IAR project demo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ; STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: demo.hex
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group StdPeriph_Driver
    STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_gpio.c stm8s_tim1.c stm8s_uart1.c
  group user
    ./: delay.c iompu6050.c M5StickC.c main.c stm8s_conf.h stm8s_it.c stm8s_it.h timer1_config.c uart.c
    STM8S_StdPeriph_Driver/inc/: stm8s.h
